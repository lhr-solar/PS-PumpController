File: Fans+Pump.kicad_sch (KiCad schematic)
At the start: 20 parts, among them Q1 PSMN8R5-40MSDX, Q2 PSMN8R5-40MSDX, U2 EMC2305-1-AP-TR

Commit message: major schem fixes
Parts:
- removed FAN1, FAN2: Conn_01x03, Connector_Molex:Molex_Nano-Fit_105309-xx03_1x03_P2.50mm_Vertical, symbol Connector_Generic:Conn_01x03
- removed Q1, Q2: PSMN8R5-40MSDX, Package_TO_SOT_SMD:LFPAK33, symbol Transistor_FET:BUK7M27-80EX
- removed R1, R3: 5k, Resistor_SMD:R_0603_1608Metric, symbol Device:R_US
- removed R2, R4: 100k, Resistor_SMD:R_0603_1608Metric, symbol Device:R_US
- removed R5: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R_US
- added D9: VSSAF522-M3/H, DO-221AC-2:SODFL5026X125N, symbol Diode:C3D25170H
- added JP3, JP4: Jumper_3_Open, Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical, symbol Jumper:Jumper_3_Open
- added R29: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R_US
- D7, D8: footprint Package_TO_SOT_THT:TO-247-2_Vertical -> DO-221AC-2:SODFL5026X125N
- R8, R9: value 10k -> 5k
Connections:
- net NET1 is gone; now on net GND: D7.2 (A)
- net NET2 is gone; now on net GND: D8.2 (A)
- net +24V: now also D9.1 (K)
- net +3.3V: now also R29.2
- net FAN1_PWM: now also U2.5 (PWM1); no longer R8.1, U2.7 (PWM2)
- net FAN1_TACH: now also R8.1, U2.6 (TACH1); no longer U2.8 (TACH2)
- net FAN2_PWM: now also U2.7 (PWM2); no longer R9.1, U2.5 (PWM1)
- net FAN2_TACH: now also R9.1, U2.8 (TACH2); no longer U2.6 (TACH1)
- net FAN_SCL: now also R7.1; no longer R6.1
- net FAN_SDA: now also R6.1
- net GND: now also D9.2 (A)
- net ~{SMBALERT}: now also R29.1; no longer R7.1
- net PUMP_TACH_CHIP: now reaches U2.10 (TACH3)
- net PUMP_TACH_CHIP: now also JP4.3 (B)
- net PUMP_PWM_CHIP: now reaches U2.9 (PWM3)
- net PUMP_PWM_CHIP: now also JP3.3 (B)
- new net PUMP_PWM: JP3.2 (C)
- new net PUMP_PWM_PSOM: JP3.1 (A)
- new net PUMP_TACH: JP4.2 (C)
- new net PUMP_TACH_PSOM: JP4.1 (A)
- no-connect marks 6 -> 4
Other:
- note added: "2x fan, 1x pump"
- note added: "Fan PWM pins configed as open drain"
- note added: "Pump PWM pin configed as push pull"
- note removed: "PWM pins configed as open drain"
- moved on the sheet: C1, C2, D7, D8, R10, R11, R6, R8, R9, U2

Commit message: schem review changes
Parts:
- added R32: 5k, Resistor_SMD:R_0603_1608Metric, symbol Device:R_US
Connections:
- net +24V: no longer D9.1 (K)
- net +3.3V: now also R32.2
- net PUMP_TACH: now also R32.1
- new net +12V: D9.1 (K)
Other:
- moved on the sheet: R9

Commit message: finalized schem
Parts:
- renumbered D8 to D12, D7 to D13, D9 to D14, JP3 to JP1, JP4 to JP2, R7 to R10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

Commit message: almost all footprints
Parts:
- C1, C2: footprint Capacitor_SMD:C_0805_2012Metric -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- D12, D13, D14: footprint DO-221AC-2:SODFL5026X125N -> UTSVT_Passive:SODFL5026X125N
- R10, R11, R12, R13, R6, R7, R8, R9: footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- U1: footprint FanControl:QFN16_4x4MC_MCH -> PumpLib:QFN16_4x4MC_MCH
Changed lines of the file:
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@@
 			"/yEhIf8hISH/ISEh/yEhIf8hISH/ISEh/yEhIf8hISH/ISEh/yEhIf8hISH/ISEh/yEhIf8hISH/"
 			"ISEh/yEhIf8hISH/ISEh/yEhIf8hISH/ISEh/yEhIf8hISH/ISEh/yEhIf8hISH/ISEh/yEhIf8h"
-			"ISH/ISEh/yEhIf8hISH/ISEh/yEhIf8hISH/IQ=="
+			"ISH/ISEh/yEhIf8hISH/ISEh/yEhIf8hISH/IQAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAPWd9V3wXfRdhr5BLOHO8V31XXcV4rPz3fLd9s2r"
+			"ltYy67vnewByHvme2CLY5/rWfBtWwY+wn/Jr/en+TH+2P89f6C/x7/NX+mvwdfMbsBy/4Jf9Tr/P"
+			"H/JHuXRsw/3tiWgH2D6Z4GRU4/Z3YFZb/N2Ee3Af/EcJH/cP+E9aFv2n/Wcsq/5zJBqByMQ+6R/3"
+			"T6p1aztmfw/2Bf4pbHX9U/5p/w01rvDPqIzPwn7Sf8e/AP6C1DHDlvf9D601/sf+FYgoIK7wr/s3"
+			"A7QaRdgnd9jfY5UDOkUX0AfA+wdyAvmqx7efxBwoCpQGylUvH6gK1AbwJFcMgN/H7dDiDgRULx8I"
+			"7+IY9lOBA5j9PaTeGTgUOAK+Gzx4oC/QHxgETw1+PDAcGAmM2eyB84EJ4EuBK+CdhwLXwBfDNQ/c"
+			"JDyrXpnAXOCu0hdYDCzZigPLgVVbJPA0sGUeaNA0pDVkNGQ15DYUNBQ3lDVUNFQ31AFzDWbTZoO9"
+			"wSNkNQQbIsxSQ1vDwYYu2OYwrO1tONZwomGo4RSsHW0423Ch4WLD5YarDdcbbgn3TAsNt00PG+Yb"
+			"7jU8MNU0PDIJDU8a1ho2giioDaYHM4PZwTzRHSwUw8GS4L5gZbAmaAgKQTnoDPoSs4O6YEgyB6PB"
+			"9mBHsFtqC/YEjwaPBweCJ4OnhYi5JHgmGYcHzwXHg5PBqeA01G8EZ4J3ggvB+8GHwcfBleB6cLOR"
+			"btQ16hv3NuY05jcWNZY2ljdWNdaqM1CT3MiYBHWmo84pGsVGpdGtzvIaA9IJ4HBjzPQQ+/rGA+Jg"
+			"Y2fjAXN746HGI419jf2Ng43DjSPBdeEB3tKU3jhmym483zjRmJhn8f2NV5LzWXWO2XgNzytNsnQM"
+			"z/gabyaPLo40zgKTuVLjXCPMmxJznMvCGvRqMTheX2zKa1wC+cuNq41PG7dCGnEVX4FQWigjlKXG"
+			"KsL1UG6oQAyHikNl5spQRag6VBfiQuaQXZ0PhjyhYCgSagsdDHXhOCd0ONQbOiZo8Mw6dILwUOhU"
+			"aBRmzRBo1V/FHDpLZtPLpH4BHyV0UeXQ5RDMjkPXpYvCvdCt0G2Y88L8NzQfuhd6kKg/IvwEx0uh"
+			"NfVK4tlraCPB0Ksm1KRtSm9Cap1wZlN2U55Y2lTYVAKzV5jDNu1rqmyqUWesTYZdLIhbTbK42ORs"
+			"8gGHMOM5pv20yk3RpnZ1XtnU0dTd1CMVNB1tOg4M7dAy0HRSnWM2nd7FZ3AU13SO8LjKTZNNUzBz"
+			"hPlj03TTjaYZM8KzyKY7TQtN982FTQ+bHgOvNK2bK5s2w3RwEt+XsI6w3pQe3huaD+eE8yVzuChc"
+			"akbh8nCVuTJcG2b4vrAYVsJuPHdQ/RG2XWAVOw=="
 		)
 	)
@@
 			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
 			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
+			"AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA"
 			"AA=="
 		)
@@
 			)
 		)
-		(property "Footprint" "Resistor_SMD:R_0603_1608Metric"
+		(property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder"
 			(at 162.814 51.816 90)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Resistor_SMD:R_0603_1608Metric"
+		(property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder"
 			(at 162.814 28.956 90)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "DO-221AC-2:SODFL5026X125N"
+		(property "Footprint" "UTSVT_Passive:SODFL5026X125N"
 			(at 122.555 95.25 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Resistor_SMD:R_0603_1608Metric"
+		(property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder"
 			(at 61.214 28.956 90)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Resistor_SMD:R_0603_1608Metric"
+		(property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder"
 			(at 244.094 28.956 90)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Capacitor_SMD:C_0805_2012Metric"
+		(property "Footprint" "Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder"
 			(at 34.29 41.91 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "FanControl:QFN16_4x4MC_MCH"
+		(property "Footprint" "PumpLib:QFN16_4x4MC_MCH"
 			(at 66.04 33.02 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "DO-221AC-2:SODFL5026X125N"
+		(property "Footprint" "UTSVT_Passive:SODFL5026X125N"
 			(at 100.965 95.25 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Capacitor_SMD:C_0805_2012Metric"
+		(property "Footprint" "Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder"
 			(at 25.4 41.91 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Resistor_SMD:R_0603_1608Metric"
+		(property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder"
 			(at 217.424 51.816 90)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Resistor_SMD:R_0603_1608Metric"
+		(property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder"
 			(at 124.714 40.386 90)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Resistor_SMD:R_0603_1608Metric"
+		(property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder"
 			(at 40.894 31.496 90)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Resistor_SMD:R_0603_1608Metric"
+		(property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder"
 			(at 217.424 28.956 90)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "DO-221AC-2:SODFL5026X125N"
+		(property "Footprint" "UTSVT_Passive:SODFL5026X125N"
 			(at 145.415 95.25 0)
 			(effects

Commit message: subcircuit layout
Parts:
- removed D12: VSSAF522-M3/H, UTSVT_Passive:SODFL5026X125N, symbol Diode:C3D25170H
Other:
- note added: "1x fans, 1x pump"
- note removed: "2x fan, 1x pump"
- moved on the sheet: D13, D14

Commit message: main circuitry done
Parts:
- renumbered JP2 to JP1, JP1 to JP2
Other:
- moved on the sheet: JP1, JP2
Changed lines of the file:
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@@
 	(wire
 		(pts
-			(xy 63.5 83.82) (xy 62.23 83.82)
+			(xy 62.23 106.68) (xy 60.96 106.68)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 54.61 91.44) (xy 55.88 91.44)
+			(xy 53.34 114.3) (xy 54.61 114.3)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 55.88 113.03) (xy 55.88 109.22)
+			(xy 54.61 92.71) (xy 54.61 88.9)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 63.5 105.41) (xy 62.23 105.41)
+			(xy 62.23 85.09) (xy 60.96 85.09)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 55.88 91.44) (xy 55.88 87.63)
+			(xy 54.61 114.3) (xy 54.61 110.49)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 46.99 83.82) (xy 49.53 83.82)
+			(xy 45.72 106.68) (xy 48.26 106.68)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 54.61 113.03) (xy 55.88 113.03)
+			(xy 53.34 92.71) (xy 54.61 92.71)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 46.99 105.41) (xy 49.53 105.41)
+			(xy 45.72 85.09) (xy 48.26 85.09)
 		)
 		(stroke
@@
 	)
 	(label "PUMP_TACH_CHIP"
-		(at 63.5 105.41 0)
+		(at 62.23 85.09 0)
 		(effects
 			(font
@@
 	)
 	(label "PUMP_PWM_CHIP"
-		(at 63.5 83.82 0)
+		(at 62.23 106.68 0)
 		(effects
 			(font
@@
 	(hierarchical_label "PUMP_TACH"
 		(shape input)
-		(at 54.61 113.03 180)
+		(at 53.34 92.71 180)
 		(effects
 			(font
@@
 	(hierarchical_label "PUMP_PWM_PSOM"
 		(shape input)
-		(at 46.99 83.82 180)
+		(at 45.72 106.68 180)
 		(effects
 			(font
@@
 	(hierarchical_label "PUMP_PWM"
 		(shape output)
-		(at 54.61 91.44 180)
+		(at 53.34 114.3 180)
 		(effects
 			(font
@@
 	(hierarchical_label "PUMP_TACH_PSOM"
 		(shape output)
-		(at 46.99 105.41 180)
+		(at 45.72 85.09 180)
 		(effects
 			(font
@@
 	(symbol
 		(lib_id "Jumper:Jumper_3_Open")
-		(at 55.88 105.41 0)
+		(at 54.61 85.09 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "JP2"
-			(at 55.88 99.06 0)
+		(property "Reference" "JP1"
+			(at 54.61 78.74 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "Jumper_3_Open"
-			(at 55.88 101.6 0)
+			(at 54.61 81.28 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical"
-			(at 55.88 105.41 0)
+			(at 54.61 85.09 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" "~"
-			(at 55.88 105.41 0)
+			(at 54.61 85.09 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Jumper, 3-pole, both open"
-			(at 55.88 105.41 0)
+			(at 54.61 85.09 0)
 			(effects
 				(font
@@
 			(project "PTN-PumpControlBoard"
 				(path "/591f46f8-eb1d-42dc-a4cb-8182eac4ef58/d90f7da4-ca39-48c6-8d97-b8d1e37c7dd0"
-					(reference "JP2")
+					(reference "JP1")
 					(unit 1)
 				)
@@
 	(symbol
 		(lib_id "Jumper:Jumper_3_Open")
-		(at 55.88 83.82 0)
+		(at 54.61 106.68 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "JP1"
-			(at 55.88 77.47 0)
+		(property "Reference" "JP2"
+			(at 54.61 100.33 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "Jumper_3_Open"
-			(at 55.88 80.01 0)
+			(at 54.61 102.87 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical"
-			(at 55.88 83.82 0)
+			(at 54.61 106.68 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" "~"
-			(at 55.88 83.82 0)
+			(at 54.61 106.68 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Jumper, 3-pole, both open"
-			(at 55.88 83.82 0)
+			(at 54.61 106.68 0)
 			(effects
 				(font
@@
 			(project "PTN-PumpControlBoard"
 				(path "/591f46f8-eb1d-42dc-a4cb-8182eac4ef58/d90f7da4-ca39-48c6-8d97-b8d1e37c7dd0"
-					(reference "JP1")
+					(reference "JP2")
 					(unit 1)
 				)

Commit message: it's almost prettyyy
Parts:
- JP1: value Jumper_3_Open -> P_Tach
- JP2: value Jumper_3_Open -> P_PWM
Changed lines of the file:
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@@
 			)
 		)
-		(property "Value" "Jumper_3_Open"
+		(property "Value" "P_Tach"
 			(at 54.61 81.28 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "Jumper_3_Open"
+		(property "Value" "P_PWM"
 			(at 54.61 102.87 0)
 			(effects
