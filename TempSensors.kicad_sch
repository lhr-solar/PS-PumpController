File: TempSensors.kicad_sch (KiCad schematic)
At the start: 12 parts, among them U3 TLV6001DCK, U4 TLV6001DCK, U5 TLV6001DCK

Commit message: reworked layout with 24V components but no testpoints & headers
Connections:
- net AGND: now also TEMP1.2 (Pin_2), TEMP2.2 (Pin_2), TEMP3.2 (Pin_2); no longer TEMP1.1 (Pin_1), TEMP2.1 (Pin_1), TEMP3.1 (Pin_1)
- net at R7.2, U3.1 (+): now also TEMP1.1 (Pin_1); no longer TEMP1.2 (Pin_2)
- net at R8.2, U4.1 (+): now also TEMP2.1 (Pin_1); no longer TEMP2.2 (Pin_2)
- net at R9.2, U5.1 (+): now also TEMP3.1 (Pin_1); no longer TEMP3.2 (Pin_2)
Other:
- moved on the sheet: TEMP1, TEMP2, TEMP3
Changed lines of the file:
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@@
+	(wire
+		(pts
+			(xy 196.85 72.39) (xy 203.2 72.39)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
 	(wire
 		(pts
@@
 	(wire
 		(pts
+			(xy 44.45 72.39) (xy 50.8 72.39)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 160.02 64.77) (xy 156.21 64.77)
 		)
@@
 	(wire
 		(pts
+			(xy 120.65 72.39) (xy 127 72.39)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 127 77.47) (xy 127 72.39)
 		)
@@
 	(wire
 		(pts
-			(xy 50.8 72.39) (xy 44.45 72.39)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 50.8 62.23) (xy 63.5 62.23)
 		)
@@
 	(wire
 		(pts
-			(xy 203.2 72.39) (xy 196.85 72.39)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 203.2 48.26) (xy 203.2 50.8)
 		)
@@
 		(pts
 			(xy 127 58.42) (xy 127 62.23)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
-			(xy 127 72.39) (xy 120.65 72.39)
 		)
 		(stroke
@@
 	(symbol
 		(lib_id "Connector_Generic:Conn_01x02")
-		(at 115.57 72.39 180)
-		(unit 1)
-		(exclude_from_sim no)
-		(in_bom yes)
-		(on_board yes)
-		(dnp no)
-		(fields_autoplaced yes)
+		(at 115.57 69.85 0)
+		(mirror y)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
 		(property "Reference" "TEMP2"
-			(at 115.57 63.5 0)
+			(at 115.57 78.74 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "Conn_01x02"
-			(at 115.57 66.04 0)
+			(at 115.57 76.2 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" "Connector_Molex:Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical"
-			(at 115.57 72.39 0)
+			(at 115.57 69.85 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" "https://koolance.com/files/products/manuals/Koolance_sen-ap008g_specifications.pdf"
-			(at 115.57 72.39 0)
+			(at 115.57 69.85 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Generic connector, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/)"
-			(at 115.57 72.39 0)
+			(at 115.57 69.85 0)
 			(effects
 				(font
@@
 	(symbol
 		(lib_id "Connector_Generic:Conn_01x02")
-		(at 191.77 72.39 180)
-		(unit 1)
-		(exclude_from_sim no)
-		(in_bom yes)
-		(on_board yes)
-		(dnp no)
-		(fields_autoplaced yes)
+		(at 191.77 69.85 0)
+		(mirror y)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
 		(property "Reference" "TEMP3"
-			(at 191.77 63.5 0)
+			(at 191.77 78.74 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "Conn_01x02"
-			(at 191.77 66.04 0)
+			(at 191.77 76.2 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" "Connector_Molex:Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical"
-			(at 191.77 72.39 0)
+			(at 191.77 69.85 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" "https://koolance.com/files/products/manuals/Koolance_sen-ap008g_specifications.pdf"
-			(at 191.77 72.39 0)
+			(at 191.77 69.85 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Generic connector, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/)"
-			(at 191.77 72.39 0)
+			(at 191.77 69.85 0)
 			(effects
 				(font
@@
 	(symbol
 		(lib_id "Connector_Generic:Conn_01x02")
-		(at 39.37 72.39 180)
-		(unit 1)
-		(exclude_from_sim no)
-		(in_bom yes)
-		(on_board yes)
-		(dnp no)
-		(fields_autoplaced yes)
+		(at 39.37 69.85 0)
+		(mirror y)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
 		(property "Reference" "TEMP1"
-			(at 39.37 63.5 0)
+			(at 39.37 78.74 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "Conn_01x02"
-			(at 39.37 66.04 0)
+			(at 39.37 76.2 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" "Connector_Molex:Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical"
-			(at 39.37 72.39 0)
+			(at 39.37 69.85 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" "https://koolance.com/files/products/manuals/Koolance_sen-ap008g_specifications.pdf"
-			(at 39.37 72.39 0)
+			(at 39.37 69.85 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Generic connector, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/)"
-			(at 39.37 72.39 0)
-			(effects
-				(font
+			(at 39.37 69.85 0)
+			(effects
+				(font

Commit message: added test points and headers, AGND and 12V not fully connected
Parts:
- added T_OUT1, T_OUT2, T_OUT3, T_TP1, T_TP2, T_TP3: Pad_TP, UTSVT_Special:TestPoint_HEX_3mmID, symbol Connector:TestPoint
Connections:
- net TEMP_SEN1: now also T_TP1.1
- net TEMP_SEN2: now also T_TP2.1
- net TEMP_SEN3: now also T_TP3.1
- net at R7.2, TEMP1.1 (Pin_1), U3.1 (+): now also T_OUT1.1
- net at R8.2, TEMP2.1 (Pin_1), U4.1 (+): now also T_OUT2.1
- net at R9.2, TEMP3.1 (Pin_1), U5.1 (+): now also T_OUT3.1

Commit message: Fixed fan schematic based on review feedback
Parts:
- added C3, C4: 1uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C_Small
Connections:
- net AGND: now also C4.2; no longer U3.2 (V-)
- net VDDA: now also C3.1; no longer U3.5 (V+)
- new net: C3.2, U3.5 (V+)
- new net: C4.1, U3.2 (V-)
Other:
- moved on the sheet: R10

Commit message: updated schematic with low pass for temp sensors and new resistor footprint
Parts:
- removed C3, C4: 1uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C_Small
- removed R10, R11, R12: 0, Resistor_SMD:R_0805_2012Metric, symbol Device:R_US
- removed R7, R8, R9: 1k, Resistor_SMD:R_0805_2012Metric, symbol Device:R_US
- removed T_OUT1, T_OUT2, T_OUT3: Pad_TP, UTSVT_Special:TestPoint_HEX_3mmID, symbol Connector:TestPoint
- removed U3, U4, U5: TLV6001DCK, Package_TO_SOT_SMD:SOT-353_SC-70-5, symbol Amplifier_Operational:TLV6001DCK
- added C10, C11, C5, C6, C7, C8, C9: 1uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C_Small
- added R1, R2, R3: 15k, Resistor_SMD:R_0603_1608Metric, symbol Device:R_US
- added R16, R25, R26, R27, R29, R30: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R_US
- added R17, R28, R31: 0, Resistor_SMD:R_0603_1608Metric, symbol Device:R_US
- added T_OUT4, T_OUT5, T_OUT6: Pad_TP, UTSVT_Special:TestPoint_HEX_3mmID, symbol Connector:TestPoint
- added U7, U8: TLV9002QDRQ1, OpAmp:SOIC127P600X175-8N, symbol Amplifier_Operational:OP249GS
Connections:
- net AGND: now also C11.2, C5.2, C6.2, C7.2, C9.2, R25.2, R27.2, R30.2
- net TEMP_SEN1: now also R17.1, U7.7
- net TEMP_SEN2: now also R28.1, U7.5
- net TEMP_SEN3: now also R31.1, U8.7
- net VDDA: now also C10.1, C8.1, R16.1, R26.1, R29.1
- net at TEMP1.1 (Pin_1): now also R1.1, R16.2, T_OUT4.1
- net at TEMP3.1 (Pin_1): now also R29.2, R3.1, T_OUT6.1
- net at TEMP2.1 (Pin_1): now also R2.1, R26.2, T_OUT5.1
- new net: C11.1, U8.2 (V-)
- new net: C10.2, U8.6 (V+)
- new net: C5.1, R1.2, U7.1 (+)
- new net: R17.2, R25.1, U7.8 (-)
- new net: C6.1, R2.2, U7.3 (+)
- new net: R30.1, R31.2, U8.8 (-)
- new net: C8.2, U7.6 (V+)
- new net: C9.1, U7.2 (V-)
- new net: R27.1, R28.2, U7.4 (-)
- new net: C7.1, R3.2, U8.1 (+)
- no-connect marks 0 -> 3
