File: PTN-PumpControlBoard.kicad_pcb (KiCad board)
At the start: 2 copper layers, 94.4 x 64.2 mm, 57 parts, among them J1 CAN_OUT, J2 CAN_IN, J3 SFH11-PBPC-D05-ST-BK, J4 SFH11-PBPC-D05-ST-BK, U1 PeripheralSOM, U2 EMC2305-1-AP-TR, U3 TLV6001DCK, U4 TLV6001DCK, U5 TLV6001DCK, U6 TLV6001DCK

Commit message: fixed VDDA and 24V but 3.3V and AGND still not working
Routing:
- net VDDA: track 10.8 -> 13.2 mm
- net GND: track 13.4 -> 14.9 mm
- net +24V: track 3.29 -> 4.46 mm
- net /~{SMBALERT}: vias 1 -> 2
Changed lines of the file:
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@@
 	)
 	(segment
-		(start 116.28113 119.425)
-		(end 117.575 119.425)
-		(width 0.5)
-		(layer "F.Cu")
-		(net 1)
-	)
-	(segment
-		(start 117.575 119.425)
-		(end 118.4 118.6)
+		(start 116.375 119.425)
+		(end 117.8 118)
 		(width 0.5)
 		(layer "F.Cu")
@@
 	)
 	(segment
+		(start 116.28113 119.425)
+		(end 116.375 119.425)
+		(width 0.5)
+		(layer "F.Cu")
+		(net 1)
+	)
+	(segment
 		(start 123.68854 117.72896)
 		(end 123.68854 119.08854)
@@
 	)
 	(segment
-		(start 114.8 119.84387)
-		(end 114.8 118.4)
-		(width 0.2)
-		(layer "F.Cu")
-		(net 2)
-	)
-	(segment
 		(start 70.27661 140.90387)
 		(end 68.89613 140.90387)
@@
 	)
 	(segment
+		(start 117.975 120.225)
+		(end 120 118.2)
+		(width 0.4)
+		(layer "F.Cu")
+		(net 2)
+	)
+	(segment
 		(start 68.89613 140.90387)
 		(end 68.4 141.4)
@@
 	(segment
 		(start 116.28113 120.225)
-		(end 115.18113 120.225)
-		(width 0.2)
-		(layer "F.Cu")
-		(net 2)
-	)
-	(segment
-		(start 115.18113 120.225)
-		(end 114.8 119.84387)
-		(width 0.2)
+		(end 117.975 120.225)
+		(width 0.4)
 		(layer "F.Cu")
 		(net 2)
@@
 	)
 	(via
-		(at 114.8 118.4)
-		(size 0.9)
-		(drill 0.5)
-		(layers "F.Cu" "B.Cu")
-		(net 2)
-	)
-	(via
 		(at 73.8 148.65387)
 		(size 0.8)
@@
 		(net 2)
 	)
+	(via
+		(at 120 118.2)
+		(size 0.9)
+		(drill 0.5)
+		(layers "F.Cu" "B.Cu")
+		(net 2)
+	)
+	(segment
+		(start 139.2 141.2)
+		(end 139.2 140.2)
+		(width 0.3)
+		(layer "F.Cu")
+		(net 3)
+	)
 	(segment
 		(start 119.05 124)
@@
 	)
 	(segment
+		(start 138.75 139.75)
+		(end 136.0125 139.75)
+		(width 0.3)
+		(layer "F.Cu")
+		(net 3)
+	)
+	(segment
+		(start 139.2 140.2)
+		(end 138.75 139.75)
+		(width 0.3)
+		(layer "F.Cu")
+		(net 3)
+	)
+	(segment
 		(start 135.8275 150.8)
 		(end 134.77263 150.8)
@@
 	)
 	(segment
-		(start 138.75 139.75)
-		(end 139.6 140.6)
-		(width 0.3)
-		(layer "F.Cu")
-		(net 3)
-	)
-	(segment
 		(start 114.44213 155.15787)
 		(end 114 155.6)
@@
 		(net 3)
 	)
-	(segment
-		(start 136.0125 139.75)
-		(end 138.75 139.75)
-		(width 0.3)
-		(layer "F.Cu")
-		(net 3)
-	)
 	(via
 		(at 134.3805 151.19213)
@@
 	)
 	(via
-		(at 139.6 140.6)
+		(at 139.2 141.2)
 		(size 0.7)
 		(drill 0.4)
@@
 	)
 	(segment
+		(start 115.175 127.425)
+		(end 112.8 129.8)
+		(width 0.5)
+		(layer "F.Cu")
+		(net 5)
+	)
+	(segment
 		(start 116.28113 127.425)
-		(end 117.625 127.425)
-		(width 0.5)
-		(layer "F.Cu")
-		(net 5)
-	)
-	(segment
-		(start 117.625 127.425)
-		(end 119 128.8)
+		(end 115.175 127.425)
 		(width 0.5)
 		(layer "F.Cu")
@@
 	(segment
 		(start 122.38854 113.830558)
-		(end 117.575572 113.830558)
+		(end 120.2 113.830558)
 		(width 0.2)
 		(layer "F.Cu")
@@
 	)
 	(segment
-		(start 113.703065 117.703065)
-		(end 113.403065 118.003065)
-		(width 0.2)
-		(layer "F.Cu")
-		(net 7)
-	)
-	(segment
-		(start 117.575572 113.830558)
-		(end 113.703065 117.703065)
-		(width 0.2)
-		(layer "F.Cu")
-		(net 7)
-	)
-	(segment
 		(start 122.38854 112.21354)
 		(end 122.2 112.025)
 		(width 0.2)
 		(layer "F.Cu")
+		(net 7)
+	)
+	(via
+		(at 120.2 113.830558)
+		(size 0.6)
+		(drill 0.3)
+		(layers "F.Cu" "B.Cu")
 		(net 7)
 	)
@@
 	)
 	(segment
+		(start 120.2 113.830558)
+		(end 117.575572 113.830558)
+		(width 0.2)
+		(layer "B.Cu")
+		(net 7)
+	)
+	(segment
 		(start 120.86 142.0066)
 		(end 113.2 134.3466)
+		(width 0.2)
+		(layer "B.Cu")
+		(net 7)
+	)
+	(segment
+		(start 113.703065 117.703065)
+		(end 113.403065 118.003065)
+		(width 0.2)
+		(layer "B.Cu")
+		(net 7)
+	)
+	(segment
+		(start 117.575572 113.830558)
+		(end 113.703065 117.703065)
 		(width 0.2)
 		(layer "B.Cu")
@@
 	)
 	(segment
+		(start 137.9125 139.1)
+		(end 140.3 139.1)
+		(width 0.3)
+		(layer "F.Cu")
+		(net 28)
+	)
+	(segment
 		(start 118.975 122.625)
 		(end 120.225 122.625)
@@
 	)
 	(segment
+		(start 116.28113 126.625)
+		(end 120.4 126.625)
+		(width 0.2)
+		(layer "F.Cu")
+		(net 31)
+	)
+	(segment
 		(start 123.4 144.5466)
 		(end 123.4 145.798775)
@@
 	)
 	(segment
+		(start 122 132)
+		(end 122 144.398774)
+		(width 0.2)
+		(layer "F.Cu")
+		(net 31)
+	)
+	(segment
+		(start 122 128.2)
+		(end 122 132)
+		(width 0.2)
+		(layer "F.Cu")
+		(net 31)
+	)
+	(segment
 		(start 132 155.101735)
 		(end 132.2 155.101735)
@@
 	)
 	(segment
-		(start 120.025 126.625)
-		(end 122 128.6)
-		(width 0.2)
-		(layer "F.Cu")
-		(net 31)
-	)
-	(segment
 		(start 137.7275 153.985)
 		(end 137.7125 154)
@@
 	)
 	(segment
-		(start 116.28113 126.625)
-		(end 120.025 126.625)
+		(start 120.425 126.625)
+		(end 122 128.2)
 		(width 0.2)
 		(layer "F.Cu")
@@
 	)
 	(segment
-		(start 122 128.6)
-		(end 122 144.398774)
+		(start 122 144.398774)
+		(end 123.500613 145.899387)
 		(width 0.2)
 		(layer "F.Cu")
@@
 	)
 	(segment
-		(start 122 144.398774)
-		(end 123.500613 145.899387)
-		(width 0.2)
-		(layer "F.Cu")
-		(net 31)
-	)
-	(segment
 		(start 137.74 151.4625)
 		(end 137.7275 151.45)
@@
 		(width 0.2)
 		(layer "F.Cu")
+		(net 31)
+	)
+	(segment
+		(start 120.4 126.625)
+		(end 120.425 126.625)
+		(width 0.2)
+		(layer "B.Cu")
 		(net 31)
 	)
@@
 		(polygon
 			(pts
-				(xy 138 108.4) (xy 138 101.747393) (xy 141.6 101.765102) (xy 141.4 133.6) (xy 138.2 133.6) (xy 138.2 121.8)
+				(xy 138 108.4) (xy 138 101.747393) (xy 141.6 101.765102) (xy 141.6 134.4) (xy 125.6 134.4) (xy 125.6 121.8)
 				(xy 114 121.8) (xy 113.973335 125.2) (xy 85.6 125) (xy 85.415377 147.4) (xy 67.6 147.4) (xy 67.6 119.2)
 				(xy 66.2 119.2) (xy 66.2 108.2)
@@
 		(polygon
 			(pts
-				(xy 120.8 125.2) (xy 114.041574 125.2) (xy 114.068239 121.8) (xy 127.150819 121.8) (xy 127.203225 135.2)
-				(xy 155.61 135.2) (xy 156 166) (xy 102.8 166) (xy 102.8 148.8) (xy 103.4 132.4) (xy 120.8 132.6)
+				(xy 120.8 125.2) (xy 114.041574 125.2) (xy 114.068239 121.8) (xy 125.6 121.8) (xy 125.6 134.4) (xy 155.388388 134.4)
+				(xy 156 166) (xy 102.8 166) (xy 102.8 148.8) (xy 103.4 132.4) (xy 120.8 132.6)
 			)
 		)

Commit message: filled zones finally workinggggg
Parts:
- added J5: PPTC032LFBN-RC, Headers:SULLINS_PPTC032LFBN-RC, F.Cu at (166.4, 87.8)
- J3, J4: value SFH11-PBPC-D05-ST-BK -> PPTC032LFBN-RC; footprint Headers:CONN_SFH11-xxxC-D05-ST-XX_SUL -> Headers:SULLINS_PPTC032LFBN-RC
- moved J4 95.7 mm to (164.5, 104.0), turned to -90 degrees
- moved P_FG1 62.3 mm to (116.6, 67.8)
- moved J3 61.6 mm to (114.5, 83.3), turned to -90 degrees
- moved C1 56.8 mm to (172.4, 82.6)
- moved C2 56.8 mm to (174.6, 82.6)
- moved FAN2 56.8 mm to (188.5, 85.8)
- moved FLOW1 56.8 mm to (104.5, 109.4)
- moved FL_OUT1 56.8 mm to (105.2, 98.0)
- moved F_TACH1 56.8 mm to (172.0, 74.6)
- moved F_TACH2 56.8 mm to (172.6, 92.2)
- moved G*** 56.8 mm to (178.8, 120.8)
- moved GND1 56.8 mm to (178.4, 87.2)
- moved GND2 56.8 mm to (108.4, 91.8)
- moved H2 56.8 mm to (190.6, 63.6)
- moved J2 56.8 mm to (138.8, 119.3)
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Connections:
- J3 pad 1: /TEMP3 -> /PUMP_PWM
- J3 pad 2: /TEMP2 -> /FLOW
- J3 pad 3: /~{SMBALERT} -> /PUMP_FG
- J3 pad 4: /TEMP1 -> unconnected-(J3-Pad4)
- J3 pad 5: /FAN_SCL -> unconnected-(J3-Pad5)
- J3 pad 6: /FAN2_PWM -> unconnected-(J3-Pad6)
- J4 pad 1: /PUMP_PWM -> /TEMP3
- J4 pad 2: /FLOW -> /TEMP2
- J4 pad 3: /PUMP_FG -> /~{SMBALERT}
- J4 pad 4: unconnected-(J4-Pad4) -> /TEMP1
Routing:
- net /FAN_SCL: track 33.8 -> 14.5 mm, vias 2 -> 0
- net /FAN1_TACH: track 59.5 -> 45.0 mm, vias 1 -> 2
- net /FAN1_PWM: track 54.7 -> 41.3 mm, vias 1 -> 2
- net /FAN_SDA: track 25.5 -> 13.0 mm
- net /FAN2_TACH: track 61.2 -> 65.5 mm
- net /PUMP_FG: track 70.4 -> 72.5 mm
- net GND: track 14.9 -> 16.7 mm
- net /PUMP_PWM: track 75.8 -> 74.0 mm
- net /TEMP2: track 52.8 -> 51.3 mm
- net /FAN2_PWM: track 54.9 -> 56.2 mm, vias 0 -> 1
- net +3.3V: track 6.07 -> 7.31 mm
- net VDDA: track 13.2 -> 12.4 mm
