File: PTN-PumpControlBoard.kicad_pcb (KiCad board)
At the start: 2 copper layers, 93.2 x 72.4 mm, 43 parts, among them Q1 NMOS, Q2 NMOS, Q3 NMOS, SW1 SW_Push, SW2 SW_Push, SW3 SW_Push, U1 EMC2305-1-AP-TR, U2 PeripheralSOM, U3 ST7735R

Commit message: reworked layout with 24V components but no testpoints & headers
Parts:
- removed C3, C4, C5: 0.1uF, Capacitor_SMD:C_0805_2012Metric
- removed CAN: PeripheralCANConnector, UTSVT_Connectors:Molex_MicroFit3.0_1x4xP3.00mm_PolarizingPeg_Vertical
- removed D2: 1N4448W, Diode_SMD:D_SOD-323
- removed Q1, Q2, Q3: NMOS, Package_TO_SOT_SMD:SOT-23
- removed R16, R19, R20: 10k, Resistor_SMD:R_0805_2012Metric
- removed R17, R18: 1k, Resistor_SMD:R_0805_2012Metric
- removed SW1, SW2, SW3: SW_Push, PushButton:TL3305BF160QG
- added H1: MountingHole, MountingHole:MountingHole_3.2mm_M3, F.Cu at (21.0, 21.6)
- added H2: MountingHole, MountingHole:MountingHole_3.2mm_M3, F.Cu at (21.0, 29.6)
- added H3: MountingHole, MountingHole:MountingHole_3.2mm_M3, F.Cu at (21.0, 37.5)
- added H4: MountingHole, MountingHole:MountingHole_3.2mm_M3, F.Cu at (21.0, 45.5)
- added J1: CAN_OUT, Connector_Molex:Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical, F.Cu at (80.8, 157.1)
- added J2: CAN_IN, Connector_Molex:Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical, F.Cu at (96.3, 157.1)
- added TEMP3: Conn_01x02, Connector_Molex:Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical, F.Cu at (110.9, 157.8)
- added TH1: Thermistor_PTC, Resistor_SMD:R_0603_1608Metric, F.Cu at (67.6, 149.8)
- added U4: TLV6001DCK, Package_TO_SOT_SMD:SOT-353_SC-70-5, F.Cu at (136.6, 154.7)
- added U5: TLV6001DCK, Package_TO_SOT_SMD:SOT-353_SC-70-5, F.Cu at (117.1, 154.8)
- added U6: TLV6001DCK, Package_TO_SOT_SMD:SOT-353_SC-70-5, F.Cu at (71.2, 136.7)
- D1: value 1N4448W -> D_Zener; footprint Diode_SMD:D_SOD-323 -> Diode_SMD:D_SOD-323F
- FAN1, FAN2: value Conn_01x03 -> Conn_01x04; footprint UTSVT_Connectors:Molex_MicroFit3.0_1x3xP3.00mm_PolarizingPeg_Vertical -> Connector_Molex:Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical
- FLOW1: footprint UTSVT_Connectors:Molex_MicroFit3.0_1x3xP3.00mm_PolarizingPeg_Vertical -> Connector_Molex:Molex_Nano-Fit_105309-xx03_1x03_P2.50mm_Vertical
- PUMP1: footprint UTSVT_Connectors:Molex_MicroFit3.0_1x4xP3.00mm_PolarizingPeg_Vertical -> Connector_Molex:Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical
- R10: value 10k -> 0
- R11, R12: value 1k -> 0
- R13: value 1k -> 100
- R14: value 10k -> 1.4k
- R15, R7: value 10k -> 1k
- R6, R9: value 380 -> 1k
- TEMP1, TEMP2: footprint UTSVT_Connectors:Molex_MicroFit3.0_1x2xP3.00mm_PolarizingPeg_Vertical -> Connector_Molex:Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical
- U1: value EMC2305-1-AP-TR -> PeripheralSOM; footprint FanControl:QFN16_4x4MC_MCH -> UTSVT_Special:PeripheralSOM
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Connections:
- D1 pad 1: +12V -> Net-(D1-K)
- D1 pad 2: Net-(D1-A) -> GND
- FAN1 pad 1: +12V -> +24V
- FAN1 pad 2: /Fans/TACH1_IN -> /FAN1_TACH
- FAN1 pad 3: Net-(D1-A) -> /FAN1_PWM
- FAN2 pad 1: +12V -> +24V
- FAN2 pad 2: /Fans/TACH2_IN -> /FAN2_TACH
- FAN2 pad 3: Net-(D2-A) -> /FAN2_PWM
- FLOW1 pad 1: /FlowrateSensor/FLOW_OUT -> +24V
- FLOW1 pad 2: +12V -> /FlowrateSensor/FLOW_OUT
- PUMP1 pad 1: /PUMP_PG -> +24V
- PUMP1 pad 3: +12V -> /PUMP_FG
- R1 pad 1: /~{SMBALERT} -> /FAN2_PWM
- R10 pad 1: /FAN2_PWM -> /TEMP1
- R10 pad 2: GND -> Net-(U3--)
- R11 pad 1: Net-(R11-Pad1) -> /TEMP2
- R11 pad 2: /FAN_SPEED -> Net-(U4--)
- R12 pad 1: Net-(R12-Pad1) -> /TEMP3
- R12 pad 2: /PUMP_SPEED -> Net-(U5--)
- R13 pad 1: Net-(R13-Pad1) -> Net-(U6--)
- R13 pad 2: /SYST_MODE -> GND
- R14 pad 1: Net-(R11-Pad1) -> /FLOW
- R14 pad 2: GND -> Net-(U6--)
- R15 pad 1: Net-(R12-Pad1) -> +3.3V
- R15 pad 2: GND -> /PUMP_FG
- R2 pad 1: /FAN2_PWM -> /~{SMBALERT}
- R4 pad 1: Net-(U1-CLK) -> Net-(U2-CLK)
- R5 pad 1: /Fans/TACH1_IN -> +3.3V
- R6 pad 1: /FAN1_TACH -> +3.3V
- R6 pad 2: GND -> /FAN2_TACH
- R7 pad 1: /FAN1_PWM -> VDDA
- R7 pad 2: GND -> Net-(TEMP1-Pin_1)
- R8 pad 1: /Fans/TACH2_IN -> VDDA
- R8 pad 2: /FAN2_TACH -> Net-(TEMP2-Pin_1)
- R9 pad 1: /FAN2_TACH -> VDDA
- R9 pad 2: GND -> Net-(TEMP3-Pin_1)
- TEMP1 pad 1: GND -> Net-(TEMP1-Pin_1)
- TEMP1 pad 2: /TEMP1 -> AGND
- TEMP2 pad 1: GND -> Net-(TEMP2-Pin_1)
- TEMP2 pad 2: /TEMP2 -> AGND
- U1 pad 1: /FAN_SCL -> /~{SMBALERT}
- U1 pad 10: unconnected-(U1-TACH3-Pad10) -> VDDA
- U1 pad 11: Net-(U1-CLK) -> GND
- U1 pad 12: /~{SMBALERT} -> AGND
- U1 pad 13: unconnected-(U1-PWM4-Pad13) -> /PUMP_PWM
- U1 pad 2: /FAN_SDA -> +3.3V
- U1 pad 3: +3.3V -> unconnected-(U1-SPI2_MISO-Pad3)
- U1 pad 4: unconnected-(U1-ADDR_SEL-Pad4) -> GND
- U1 pad 5: /FAN1_PWM -> unconnected-(U1-SPI2_SCK-Pad5)
- U1 pad 6: /FAN1_TACH -> /FAN_SDA
- U1 pad 7: /FAN2_PWM -> unconnected-(U1-SPI2_NSS-Pad7)
- U1 pad 8: /FAN2_TACH -> /FAN_SCL
- U1 pad 9: unconnected-(U1-PWM3-Pad9) -> +3.3V
- U2 pad 1: /MOSI -> /FAN_SCL
- U2 pad 10: VDDA -> unconnected-(U2-TACH3-Pad10)
- U2 pad 11: GND -> Net-(U2-CLK)
- U2 pad 12: AGND -> /~{SMBALERT}
- U2 pad 13: /FLOW -> unconnected-(U2-PWM4-Pad13)
- U2 pad 14: /PUMP_PWM -> unconnected-(U2-TACH4-Pad14)
- U2 pad 15: /FAN_SPEED -> unconnected-(U2-PWM5-Pad15)
- U2 pad 16: /PUMP_PG -> unconnected-(U2-TACH5-Pad16)
- U2 pad 2: +3.3V -> /FAN_SDA
- U2 pad 3: /LCD_RESET -> +3.3V
- U2 pad 4: GND -> unconnected-(U2-ADDR_SEL-Pad4)
- U2 pad 5: /SCLK -> /FAN2_PWM
- U2 pad 6: /FAN_SDA -> /FAN1_TACH
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Routing:
- net GND: track 80.4 -> 12.2 mm, vias 7 -> 8
- net /CAN_L: track 0.00 -> 61.1 mm, vias 0 -> 1
- net /CAN_H: track 0.00 -> 60.2 mm, vias 0 -> 1
- net /PUMP_FG: track 0.00 -> 55.4 mm, vias 0 -> 2
- net CAN_L: track 54.8 -> 0.00 mm, vias 1 -> 0
- net +12V: track 53.5 -> 0.00 mm, vias 1 -> 0
- net /MOSI: track 52.8 -> 0.00 mm, vias 1 -> 0
- net GNDPWR: track 54.5 -> 3.13 mm
- net CAN_H: track 50.8 -> 0.00 mm, vias 1 -> 0
- net /SCLK: track 48.6 -> 0.00 mm
- net /LCD_TFT_~{CS}: track 43.3 -> 0.00 mm
- net /LCD_RESET: track 42.6 -> 0.00 mm, vias 1 -> 0
- net /FAN_SPEED: track 41.4 -> 0.00 mm
- net /PUMP_SPEED: track 37.3 -> 0.00 mm
- net /PUMP_PG: track 34.9 -> 0.00 mm
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- added copper zone on F.Cu, net +24V
- added copper zone on B.Cu, net AGND
- added copper zone on B.Cu, net GNDPWR
- added copper zone on F.Cu, net VDDA
- removed copper zone on F.Cu, net +12V
Other:
- board size 93.2 x 72.4 mm -> 96 x 64 mm

Commit message: added test points and headers, AGND and 12V not fully connected
Parts:
- added FL_OUT1: Scope_TP, TestPoint:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (62.8, 135.8)
- added FL_TP1: Scope_TP, TestPoint:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (69.4, 135.8)
- added F_PWM1: Scope_TP, TestPoint:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (136.8, 112.4)
- added F_PWM2: Scope_T1, TestPoint:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (136.8, 131.2)
- added F_TACH1: Scope_TP, TestPoint:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (129.6, 112.4)
- added F_TACH2: Scope_TP, TestPoint:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (130.2, 130.0)
- added G***: LOGO, LOGO, F.Cu at (136.4, 158.6)
- added GND1: Scope_TP, TestPoint:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (136.0, 125.0)
- added GND2: Scope_TP, TestPoint:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (66.0, 129.6)
- added J3: SFH11-PBPC-D05-ST-BK, Headers:CONN_SFH11-xxxC-D05-ST-XX_SUL, F.Cu at (120.9, 144.5)
- added J4: SFH11-PBPC-D05-ST-BK, Headers:CONN_SFH11-xxxC-D05-ST-XX_SUL, F.Cu at (70.8, 123.5)
- added P_FG1: Scope_TP, TestPoint:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (67.2, 105.8)
- added P_PWM1: Scope_TP, TestPoint:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (73.0, 105.8)
- added T_OUT1: Pad_TP, UTSVT_Special:TestPoint_HEX_3mmID, F.Cu at (129.8, 138.0)
- added T_OUT2: Pad_TP, UTSVT_Special:TestPoint_HEX_3mmID, F.Cu at (129.6, 149.2)
- added T_OUT3: Pad_TP, UTSVT_Special:TestPoint_HEX_3mmID, F.Cu at (124.0, 153.2)
- added T_TP1: Pad_TP, UTSVT_Special:TestPoint_HEX_3mmID, F.Cu at (129.8, 142.6)
- added T_TP2: Pad_TP, UTSVT_Special:TestPoint_HEX_3mmID, F.Cu at (129.6, 154.0)
- added T_TP3: Pad_TP, UTSVT_Special:TestPoint_HEX_3mmID, F.Cu at (124.2, 158.2)
- moved H4 169.9 mm to (148.2, 158.2)
- moved H2 146.1 mm to (148.2, 101.4)
- moved H3 127.2 mm to (61.4, 158.2)
- moved H1 89.6 mm to (61.4, 101.6)
- moved TH1 8.47 mm to (68.6, 158.2), turned to 90 degrees
- moved D1 6.65 mm to (68.6, 154.7), turned to 90 degrees
- moved R11 4.80 mm to (136.8, 154.0)
- moved FAN1 4.71 mm to (145.8, 108.8)
- moved R3 4.71 mm to (141.0, 117.3)
- moved R5 4.71 mm to (141.0, 107.5)
- moved R2 4.31 mm to (122.2, 111.1)
- moved U2 4.31 mm to (123.4, 115.8)
- moved R4 4.31 mm to (124.4, 111.1)
- moved FLOW1 4.20 mm to (62.1, 147.2)
- moved R13 4.20 mm to (71.4, 148.7)
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Connections:
- U1 pad 17: /PUMP_FG -> unconnected-(U1-SPI1_MOSI-Pad17)
- U1 pad 3: unconnected-(U1-SPI2_MISO-Pad3) -> /PUMP_FG
Routing:
- net /FAN2_TACH: track 25.5 -> 61.2 mm
- net /FAN1_PWM: track 19.1 -> 54.7 mm, vias 0 -> 1
- net /FAN1_TACH: track 27.6 -> 59.5 mm
- net /TEMP3: track 3.64 -> 33.3 mm
- net /FAN2_PWM: track 25.7 -> 54.9 mm
- net /PUMP_PWM: track 50.3 -> 75.8 mm, vias 0 -> 1
- net /FLOW: track 47.7 -> 70.4 mm, vias 0 -> 2
- net /~{SMBALERT}: track 19.5 -> 41.9 mm, vias 0 -> 1
- net /TEMP1: track 38.5 -> 59.1 mm
- net /FAN_SCL: track 15.9 -> 33.8 mm
- net /PUMP_FG: track 55.4 -> 70.4 mm, vias 2 -> 1
- net /FAN_SDA: track 13.4 -> 25.5 mm
- net Net-(TEMP2-Pin_1): track 14.9 -> 26.7 mm
- net /FlowrateSensor/FLOW_OUT: track 9.95 -> 20.2 mm
- net Net-(TEMP3-Pin_1): track 11.8 -> 19.2 mm
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Other:
- board size 96 x 64 mm -> 94.4 x 64.2 mm
