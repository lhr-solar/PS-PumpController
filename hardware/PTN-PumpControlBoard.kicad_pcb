# Repository lhr-solar/PS-PumpController

## KiCad design hardware/PTN-PumpControlBoard.kicad_pcb

File hardware/readme.md:

# PTN-PumpControlBoard
This PCB provides an interface to control the speed of a 12V pump for battery cooling on the 2026 LHR Solar car.

Parts:
D1, D2, D3, D4, D5, D6: TVS; CR_SOD-123FL_LTF
D15: PumpStatus; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D16: FanStatus; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D18: FanChipStatus; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D19: FlowStatus; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D20: Overtemp; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D21: MiscLED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D22: 24V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D23: 12V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_TopBottom
J1: PWR_CAN; Molex_Nano-Fit_105310-xx06_2x03_P2.50mm_Vertical
J2: Pump_Temp; Molex_Nano-Fit_105310-xx08_2x04_P2.50mm_Vertical
J3: Flow_Fan; CONN_SD-105310-100_14_MOL
J4: 53307-2471; PeripheralSOM
J5: SFH11-PBPC-D05-ST-BK; CONN_SFH11-xxxC-D05-ST-XX_SUL
LOGO1: Dr. Hallock; Hallock_Image_Tiny
LOGO2: LHRS; LHRs_LOGO
R39, R40, R42, R43, R44, R45: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R46: 1.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R47: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+3.3V: J4.2 (+3.3v); also elsewhere on the board
+12V: D23.2 (A), J2.1, J3.1, J3.3; also elsewhere on the board
+24V: D22.2 (A), J3.4, J3.7, J4.24 (+24V_In); also elsewhere on the board
/24V_IN: J1.1; also elsewhere on the board
/CAN_H: J1.2, J1.5, J4.22 (CAN_H)
/CAN_L: J1.3, J1.6, J4.20 (CAN_L)
/FAN1_PWM: J3.12, J5.7 (CH3); also elsewhere on the board
/FAN1_TACH: J3.5, J5.9 (CH1); also elsewhere on the board
/FAN2_PWM: J3.13; also elsewhere on the board
/FAN2_TACH: J3.6; also elsewhere on the board
/FAN_CHIP: D18.2 (A), J4.14 (SPI2_MISO)
/FAN_LED: D16.2 (A), J4.15 (ADC1_IN11)
/FAN_SCL: J4.6 (I2C1_SCL), J5.6 (CH4); also elsewhere on the board
/FAN_SDA: J4.4 (I2C1_SDA), J5.8 (CH2); also elsewhere on the board
/FLOW1: D3.2 (A2), J4.23 (SPI1_SCK), J5.5 (CH5); also elsewhere on the board
/FLOW1_SIG: J3.2; also elsewhere on the board
/FLOW2: D4.2 (A2), J4.9 (ADC1_IN7); also elsewhere on the board
/FLOW2_SIG: J3.9; also elsewhere on the board
/FLOW_LED: D19.2 (A), J4.18 (SPI2_SCK)
/LED1: D21.2 (A), J4.19 (SPI1_NSS)
/PUMP_LED: D15.2 (A), J4.7 (OPAMP1_VINP)
/PUMP_PWM: J2.6, J5.4 (CH6); also elsewhere on the board
/PUMP_TACH: J2.2, J5.3 (CH7); also elsewhere on the board
/PWM_PSOM: D1.2 (A2), J4.16 (SPI2_MOSI); also elsewhere on the board
/TACH_PSOM: D2.2 (A2), J4.21 (SPI1_MISO); also elsewhere on the board
/TEMP1: D5.2 (A2), J4.11 (ADC1_IN9); also elsewhere on the board
/TEMP2: D6.2 (A2), J4.13 (ADC1_IN10); also elsewhere on the board
/TEMP_IN1: J2.3; also elsewhere on the board
/TEMP_IN2: J2.4; also elsewhere on the board
/TEMP_LED: D20.2 (A), J4.17 (SPI1_MOSI)
/~SMBALERT: J4.12 (SPI2_NSS); also elsewhere on the board
AGND: J2.7, J2.8, J4.10 (GNDA); also elsewhere on the board
GND: D1.1 (A1), D2.1 (A1), D3.1 (A1), D4.1 (A1), D5.1 (A1), D6.1 (A1), J1.4, J2.5, J3.8, J3.10, J3.11, J3.14, J4.1 (GND), J4.3 (GND), J4.5 (GND), J5.1 (GND), J5.2 (GND), R39.2, R40.2, R42.2, R43.2, R44.2, R45.2, R46.2, R47.2; also elsewhere on the board
unnamed: D15.1 (K), R39.1
unnamed: D16.1 (K), R40.1
unnamed: D18.1 (K), R42.1
unnamed: D19.1 (K), R43.1
unnamed: D20.1 (K), R45.1
unnamed: D21.1 (K), R44.1
unnamed: D22.1 (K), R46.1
unnamed: D23.1 (K), R47.1
VDDA: J4.8 (VDDA); also elsewhere on the board

Notes on the sheet:
PA11
PB12
PA2
PA4
PA5
PB7
PB15
PB3
PB6
TVS DIODES
PERIPHERAL SOM
PSOM PINS: fan scl - pb6 fan sda - pb7 smbalert - pb12 temp 1 - pa4 temp 2 - pa5 flow 1 - pb3 flow 2 - pa2 pump pwm - pb15 pump tach - pa11 all others gpio for lights
HOLES
DEBUG LEDs
BREAKOUTS
ADDITIONAL SHEETS
CONNECTORS
LOGOS

Parts:
C3: .1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C5: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
Q1, Q2: IRLML0030TRPBF; SOT-23-3
R14, R15, R22, R23, R28, R29: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R16, R17, R24, R25: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18, R19: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R20, R21, R26, R27: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R30, R31: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP6: TEMP1; TestPoint_Pad_1.0x1.0mm
TP7: TEMP2; TestPoint_Pad_1.0x1.0mm
TP8: AGND; TestPoint_Pad_1.0x1.0mm
U2: TLV9002QDRQ1; SOIC127P600X175-8N

Connections:
+3.3V: R24.1, R25.1, R30.1, R31.1; also elsewhere on the board
/FLOW1: R24.2, R26.2, R28.2; also elsewhere on the board
/FLOW1_SIG: Q1.1 (G), R28.1; also elsewhere on the board
/FLOW2: R25.2, R27.2, R29.2; also elsewhere on the board
/FLOW2_SIG: Q2.1 (G), R29.1; also elsewhere on the board
/TEMP1: C4.1, R18.2; also elsewhere on the board
/TEMP2: C5.1, R19.2; also elsewhere on the board
/TEMP_IN1: R14.1, R16.2, TP6.1, U2.3 (+); also elsewhere on the board
/TEMP_IN2: R15.1, R17.2, TP7.1, U2.5 (+); also elsewhere on the board
AGND: C3.2, C4.2, C5.2, R22.2, R23.2, TP8.1, U2.4 (V-); also elsewhere on the board
GND: Q1.2 (S), Q2.2 (S); also elsewhere on the board
unnamed: Q1.3 (D), R26.1, R30.2
unnamed: Q2.3 (D), R27.1, R31.2
unnamed: R14.2, R18.1, R20.1, U2.1
unnamed: R15.2, R19.1, R21.1, U2.7
unnamed: R20.2, R22.1, U2.2 (-)
unnamed: R21.2, R23.1, U2.6 (-)
VDDA: C3.1, R16.1, R17.1, U2.8 (V+); also elsewhere on the board

Notes on the sheet:
If Open Drain
If Push-Pull
TEMP SENSORS: Min: -40C, 191.8k, 3.136V Max: 120C, 0.583k, 0.182V
ACTIVE FILTER CALCS: Af = 1 + 0/10k = 1 Fc = 1/(2πRC) = 1/(2π*15k*1µ) ~ 10.6 Hz
FLOWRATE SENSOR 2
TEMP 1
TEMP 2
testing notes: - took out the initial restistor divider + op amp - works with just the input, 10k pull up, and output low pass filter
- rated for 5-15 V - < 3.3mA @ 5V - Flow_In is likely square wave at same voltage as Vin
FLOWRATE SENSOR 1

Parts:
C6, C19: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; JLC C14663
C7, C20: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; JLC C440198
C8, C21: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; JLC C28323
C9, C22: 220nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; JLC C21120
C10: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C14663
C11, C13, C14, C15, C16: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C440198
C12: 220n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C344195
C17: C_Small; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; not fitted
C18: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C15849
IC1, IC2: LM74502HDDFR; SOT65P280X110-8N; Mouser Part Number 595-LM74502HDDFR
L1: 4.7u; IND-SMD_L5.0-W5.0
Q3, Q4, Q5, Q6: NVMFWS1D7N04XMT1G; NVMFWS3D0P04M8LT1G; Manufacturer_Part_Number NVMFWS1D7N04XMT1G; JLC C52190853
R32: 200k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; JLC C25811
R33, R38: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; JLC C25804
R34: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C25803
R35: 9.09k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R36: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R37: 98k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; JLC C25811
TP1: 24V_IN; TestPoint_Pad_2.0x2.0mm
TP2: 24V; TestPoint_Pad_2.0x2.0mm
TP3: 12V_IN; TestPoint_Pad_2.0x2.0mm
TP4: 12V; TestPoint_Pad_2.0x2.0mm
TP5: GND; TestPoint_Pad_2.0x2.0mm
U3: LMR33630ADDA; Texas_HSOP-8-1EP_3.9x4.9mm_P1.27mm_ThermalVias; LCSC C841384

Connections:
+12V: C20.1, Q6.5, Q6.6, Q6.7, Q6.8, Q6.9, R36.2, TP4.1; also elsewhere on the board
+24V: C7.1, C11.1, C12.1, Q4.5, Q4.6, Q4.7, Q4.8, Q4.9, TP2.1, U3.2 (VIN), U3.3 (EN); also elsewhere on the board
/24V_IN: C6.2, C8.2, C9.1, IC1.1 (EN/UVLO), IC1.5 (VS), Q3.5, Q3.6, Q3.7, Q3.8, Q3.9, R32.1, TP1.1; also elsewhere on the board
/Power/12V_BUCKED: C13.1, C14.1, C15.1, C16.1, C17.1, C19.2, C21.2, C22.1, IC2.1 (EN/UVLO), IC2.5 (VS), L1.2, Q5.5, Q5.6, Q5.7, Q5.8, Q5.9, R34.1, R36.1, R37.1, TP3.1
GND: C6.1, C7.2, C8.1, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C18.2, C19.1, C20.2, C21.1, IC1.2 (GND), IC2.2 (GND), R33.2, R35.2, R38.2, TP5.1, U3.1 (GND), U3.9 (GND); also elsewhere on the board
unnamed: IC1.6 (GATE), Q3.4, Q4.4
unnamed: IC1.7 (OV), R32.2, R33.1
unnamed: IC1.8 (SRC), Q3.1, Q3.2, Q3.3, Q4.1, Q4.2, Q4.3
unnamed: C9.2, IC1.4 (VCAP)
unnamed: IC2.6 (GATE), Q5.4, Q6.4
unnamed: IC2.7 (OV), R37.2, R38.1
unnamed: IC2.8 (SRC), Q5.1, Q5.2, Q5.3, Q6.1, Q6.2, Q6.3
unnamed: C22.2, IC2.4 (VCAP)
unnamed: C10.1, U3.7 (BOOT)
unnamed: C17.2, R34.2, R35.1, U3.5 (FB)
unnamed: C10.2, L1.1, U3.8 (SW)
unnamed: C18.1, U3.6 (VCC)

Notes on the sheet:
from datasheet
~13.5V OVP (bc pump)
from moco interface
~26V OVP
from pi board (from vcu)
1400 fsw
12V RPP AND OVP
24 -> 12V Buck
24V RPP AND OVP

Parts:
C1, C2: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D13, D14: VSSAF522-M3/H; SODFL5026X125N
R6, R10, R11: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R12: 33k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9, R13: 5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R41, R49: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R48, R50: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
U1: EMC2305-1-AP-TR; QFN16_4x4MC_MCH

Connections:
+3.3V: C1.1, C2.1, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, U1.3 (VDD); also elsewhere on the board
+12V: D14.1 (K); also elsewhere on the board
+24V: D13.1 (K); also elsewhere on the board
/FAN1_PWM: U1.5 (PWM1); also elsewhere on the board
/FAN1_TACH: R8.1, U1.6 (TACH1); also elsewhere on the board
/FAN2_PWM: U1.7 (PWM2); also elsewhere on the board
/FAN2_TACH: R9.1, U1.8 (TACH2); also elsewhere on the board
/FAN_SCL: R10.1, U1.2 (SMCLK); also elsewhere on the board
/FAN_SDA: R6.1, U1.1 (SMDATA); also elsewhere on the board
/Fans+Pump/ADDR_SEL: R12.1, U1.4 (ADDR_SEL)
/Fans+Pump/CLK: R7.1, U1.11 (CLK)
/Fans+Pump/PUMP_PWM_CHIP: R49.2, U1.9 (PWM3)
/Fans+Pump/PUMP_TACH_CHIP: R41.2, U1.10 (TACH3)
/PUMP_PWM: R49.1, R50.1; also elsewhere on the board
/PUMP_TACH: R13.1, R41.1, R48.1; also elsewhere on the board
/PWM_PSOM: R50.2; also elsewhere on the board
/TACH_PSOM: R48.2; also elsewhere on the board
/~SMBALERT: R11.1, U1.12 (*ALERT); also elsewhere on the board
GND: C1.2, C2.2, D13.2 (A), D14.2 (A), U1.HTAB (EPAD); also elsewhere on the board

Notes on the sheet:
1x fans, 1x pump
Fan PWM pins configed as open drain
Pump PWM pin configed as push pull
FLYBACK DIODES
Testing notes: - pwm only worked with push pull input at 3.3V - tach didn't work at all... I'll prob use flowrate sensors instead
FAN CONTROL IC
Pump Specs: Flowrate: 800L/hour Current: 0.7A Voltage: 12V-13.5V Power: 7W Speed: 3000-5000RPM
PULL-UPS
PUMP JUMPERS

Board: 2 copper layers, 53.1 x 81.9 mm, 114 parts (6 on the bottom side), 65 nets.

## Code that names these connections

File software/config/Inc/pindef.h:

#include"<stm32xx_hal.h"
#include "common.h"

// Fan pins
#define FAN_SCL_PORT            GPIOB
#define FAN_SCL_PIN             GPIO_PIN_6

#define FAN_SDA_PORT            GPIOB
#define FAN_SDA_PIN             GPIO_PIN_7

#define FAN_SMBALERT_PORT       GPIOB
#define FAN_SMBALERT_PIN        GPIO_PIN_12

// Pump pins
#define PUMP_PWM_PORT           GPIOB
#define PUMP_PWM_PIN            GPIO_PIN_15

#define PUMP_TACH_PORT          GPIOA
#define PUMP_TACH_PIN           GPIO_PIN_11

// Temp pins
#define TEMP1_ADC_PORT          GPIOA
#define TEMP1_ADC_PIN           GPIO_PIN_4

#define TEMP2_ADC_PORT          GPIOA
#define TEMP2_ADC_PIN           GPIO_PIN_5

// Flowrate pins
#define FLOW_TACH_PORT          GPIOB
#define FLOW_TACH_PIN           GPIO_PIN_3

// LED pins
#define PUMP_LED_PORT           GPIOA
#define PUMP_LED_PIN            GPIO_PIN_0

#define FAN_LED_PORT            GPIOA
#define FAN_LED_PIN             GPIO_PIN_6

#define FANCHIP_LED_PORT        GPIOB
#define FANCHIP_LED_PIN         GPIO_PIN_14

#define FLOW_LED_PORT           GPIOB
#define FLOW_LED_PIN            GPIO_PIN_10

#define TEMP_LED_PORT           GPIOA
#define TEMP_LED_PIN            GPIO_PIN_12

#define STATUS_LED_PORT         GPIOB
#define STATUS_LED_PIN          GPIO_PIN_0

## Commit log (part)

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2025-03-01 Create LICENSE
2025-03-01 readme
2025-03-01 initial kicad stuff
2025-03-01 submodule
2025-04-02 Initial schematic with 3 temp, 1 flow, 1 pump, 2 fans
2025-04-25 Initial layout with 1 pump, 2 temp, 1 flow all on front side
2025-04-25 modified labels, added mounting holes, and rounded corners
2025-07-28 schematic with 12V components, unigain buffers & extra temp sensor
2025-07-30 repicked parts to be 24V tolerant and changed corresponding circuitry
2025-07-31 reworked layout with 24V components but no testpoints & headers
2025-08-01 added test points and headers, AGND and 12V not fully connected
2025-08-01 fixed VDDA and 24V but 3.3V and AGND still not working
2025-08-01 filled zones finally workinggggg
2025-08-01 making in prettyyy (kinda)
2025-08-02 added +24V and GND flat test points
2025-08-02 updated pump datasheet
2025-08-06 Fixed fan schematic based on review feedback
2025-08-14 updated schematic with low pass for temp sensors and new resistor footprint
2025-08-17 added kicad bild submodule
2025-08-19 low pass for temp & flyback diodes
2025-08-21 fixed all review notes for schematic
2025-08-21 set up layout
2025-08-22 review notes
2025-08-24 schematic changes before switching submodules
2025-08-24 fixed submodule, schematic basically done
2025-08-24 fixed rpp
2025-08-24 finalized schematic (pls be the last time)
2025-08-24 cube sux
2025-08-24 fan and temp subcircuits
2025-08-24 flowrate subcircuit
2025-08-24 all subcircuits other than rpp
2025-08-24 changed rpp circuit to match vcu
2025-08-24 everything done other than the routing for logic analyzers
2025-08-24 doneee (hopefully)
2025-08-24 rounded corners and added rpp bypass
2025-08-24 datasheets disappeared for some reason
2025-08-25 fixed diodes and some traces
2025-08-26 moved psom to make room for usb
2025-08-26 usb issue resolved
2025-08-26 fixed filled zones and vias
2025-08-26 fixed header
2025-08-26 labelssss
2025-08-26 gerberssss
2025-09-03 fixed cap vals + made schem pretty
2025-09-12 RevA (#1)
    * Initial schematic with 3 temp, 1 flow, 1 pump, 2 fans
    * Added pull up resistors for open drain configs
    * Initial schematic design with 2 temp, 1 flow, 1 pump
    * Initial layout with 1 pump, 2 temp, 1 flow all on front side
    * modified labels, added mounting holes, and rounded corners
    * schematic with 12V components, unigain buffers & extra temp sensor
2025-10-02 fixed fake datasheets
2026-01-03 initial schem changes
2026-01-07 major schem fixes
2026-01-12 schem review changes
2026-01-12 finalized schem
2026-01-12 almost all footprints
2026-01-12 idk what I changed but pushing jic
2026-01-12 subcircuit layout
2026-01-13 mx150 version
2026-01-13 main circuitry done
2026-01-13 it's almost prettyyy
2026-01-13 lakshays bs
2026-01-14 almost there
2026-01-14 lookin cute
2026-01-14 pls don't crash on me again
2026-01-14 drc passingggg
2026-01-14 rounded corners and nanofit connectors
2026-01-14 bombs
2026-01-14 bomb 2.0
2026-01-14 turns out it's 2026 lmao
2026-01-14 making git pretty + bom
2026-01-15 cleanup
2026-01-15 Rev B (#2)
    * initial schem changes
    * major schem fixes
    * schem review changes
    * finalized schem
    * almost all footprints
    * idk what I changed but pushing jic
2026-01-26 basic firmware setup but blinky no work yet
2026-01-26 fixed submodule issue
2026-01-31 added workflows from vcu
2026-01-31 initial led driver
2026-02-06 better organization:
2026-02-06 it compilesgit status
2026-02-06 fixed blinky_test
2026-02-06 test description
2026-02-06 move led_configs to header
2026-02-06 workflows?
2026-02-07 added cubemx code
2026-02-07 some semblance of fan driver but doesn't compile rip
2026-02-07 compiling fan test
2026-02-10 fixing review stuff
2026-02-12 working fan test
2026-02-12 git fixes:
2026-02-12 working pump test
2026-02-14 less ugly code + working PumpFan test
2026-02-14 making sure firmware changes stay
2026-02-15 making sure submodules are right
2026-02-15 deleting stuff
2026-02-15 more deletes
2026-02-15 last delete (?)
2026-02-15 hopefully fixed?
2026-02-15 gerbers
2026-02-16 fixed 3d models
2026-02-16 fix .gitignore
    Add various entries to .gitignore for build files, Python environments, Mac specific files, Vim swap files, Nix lock files, documentation toolset, and VSCode settings.
2026-02-16 .gitmodules fix
2026-02-16 hopefully firmware setup works?
2026-02-16 Rev c (#4)
    * making sure submodules are right
    * deleting stuff
    * more deletes
    * last delete (?)
    * hopefully fixed?
    * gerbers
2026-02-17 temp not working but everything else cleaned up
2026-02-25 temp driver works! (it's really ugly tho I'll fix later)
2026-02-27 less ugly code + workflows
2026-02-27 workflows are stupid
2026-02-27 workflows are still stupid
2026-02-27 oops forgot the shell script hehe
2026-02-27 pls work
2026-02-27 acc crashing out
2026-02-27 oopsies
2026-02-27 new python script
    Updated the tests directory path and added comments for cleaning test filenames.
2026-02-27 im dumb
2026-02-27 still dumb
    Cleaned test file names by removing '_test.c' suffix.
2026-02-27 pls be the last time
2026-02-27 perhaps it builds now?
    Comment out PROJECT_BUILD_DIR in makeAllTests.py
2026-02-27 im actually an idiot
2026-03-05 working flowrate driver (ugly and fails build)
2026-03-06 workflows pls work
2026-03-06 pls work oml
2026-03-06 perhaps?
2026-03-06 #unserious
2026-03-06 #cooked
2026-03-06 erm idk why it's compiling locally but not on build rip
2026-03-06 idk anymore
2026-03-06 i'm actually stupiddddd
2026-03-06 documentation fixed
2026-03-06 fixed more reviews, added extra init func for emc
2026-03-06 less ugly temp test
2026-03-06 idk how capital letters work apparently
2026-03-07 most reviews addressed, temp table + tests remaining
2026-03-07 all reviews addressed other than config modes
2026-03-07 added configs, hopefully all reviews addressed
2026-03-07 oops forgot to check it compiles
2026-03-07 clock config changed
2026-03-07 working on hw
2026-03-07 fixing .gitmodules merge conflict
2026-03-09 Drivers (#3)
    * basic firmware setup but blinky no work yet
    * fixed submodule issue
    * added workflows from vcu
    * initial led driver
    * better organization:
    * it compilesgit status
2026-03-10 initial can loopback test working
2026-03-10 can send kinda works but took years off my life
2026-03-28 flowrate can send but not tested
2026-03-28 oops I forgot to pushed updated dbc
2026-03-28 working can send for all messages
2026-04-16 doesn't work but I wanna push it somewhere
2026-06-07 basic pde config
